FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://0001-Add-support-for-i.MX93-FRDM-board.patch \
	file://0002-Add-GoPoint-support-for-FRDM-IMX8MP.patch \
"
